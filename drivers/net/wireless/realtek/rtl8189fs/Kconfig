## drivers/net/wireless/realtek/rtl8189fs/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0
config RTL8189FS
default M
	tristate "Realtek 8189F SDIO WiFi"
	help
	  Help message of RTL8189FS
```
